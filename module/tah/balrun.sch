** sch_path: module/tah/balrun.sch
**.subckt balrun
E1 net3 net2 net1 GND 0.5
E2 net4 net2 net1 GND -0.5
V1 net1 GND 3
V2 net2 GND 3
**.ends
.GLOBAL GND
.end
