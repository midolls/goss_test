v {xschem version=3.4.0 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {/foss/designs/goss_test/module/sw_buffer.sym} 270 -210 0 0 {name=x1}
