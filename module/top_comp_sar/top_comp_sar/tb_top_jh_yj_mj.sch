v {xschem version=3.4.0 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
N 1440 -1230 1440 -1170 {
lab=tah_vp}
N 1470 -1230 1470 -1170 {
lab=tah_vp}
N 1500 -1230 1500 -1170 {
lab=tah_vp}
N 1530 -1230 1530 -1170 {
lab=tah_vp}
N 1560 -1230 1560 -1170 {
lab=tah_vp}
N 1590 -1230 1590 -1170 {
lab=tah_vp}
N 1620 -1230 1620 -1170 {
lab=tah_vp}
N 1650 -1230 1650 -1170 {
lab=tah_vp}
N 1780 -1230 1780 -1170 {
lab=tah_vp}
N 1810 -1230 1810 -1170 {
lab=tah_vp}
N 1840 -1230 1840 -1170 {
lab=tah_vp}
N 1870 -1230 1870 -1170 {
lab=tah_vp}
N 1900 -1230 1900 -1170 {
lab=tah_vp}
N 1930 -1230 1930 -1170 {
lab=tah_vp}
N 1960 -1230 1960 -1170 {
lab=tah_vp}
N 1990 -1230 1990 -1170 {
lab=tah_vp}
N 1440 -1070 1440 -1010 {
lab=tah_vn}
N 1470 -1070 1470 -1010 {
lab=tah_vn}
N 1500 -1070 1500 -1010 {
lab=tah_vn}
N 1530 -1070 1530 -1010 {
lab=tah_vn}
N 1560 -1070 1560 -1010 {
lab=tah_vn}
N 1590 -1070 1590 -1010 {
lab=tah_vn}
N 1620 -1070 1620 -1010 {
lab=tah_vn}
N 1650 -1070 1650 -1010 {
lab=tah_vn}
N 1780 -1070 1780 -1010 {
lab=tah_vn}
N 1810 -1070 1810 -1010 {
lab=tah_vn}
N 1840 -1070 1840 -1010 {
lab=tah_vn}
N 1870 -1070 1870 -1010 {
lab=tah_vn}
N 1900 -1070 1900 -1010 {
lab=tah_vn}
N 1930 -1070 1930 -1010 {
lab=tah_vn}
N 1960 -1070 1960 -1010 {
lab=tah_vn}
N 1990 -1070 1990 -1010 {
lab=tah_vn}
N 1290 -1170 1990 -1170 {
lab=tah_vp}
N 1290 -1070 1990 -1070 {
lab=tah_vn}
N 1990 -1170 2120 -1170 {
lab=tah_vp}
N 1990 -1070 2120 -1070 {
lab=tah_vn}
N 1440 -1560 1440 -1470 {
lab=result[6]}
N 1470 -1560 1470 -1470 {
lab=result[5]}
N 1500 -1560 1500 -1470 {
lab=result[4]}
N 1530 -1560 1530 -1470 {
lab=result[3]}
N 1560 -1560 1560 -1470 {
lab=result[2]}
N 1590 -1560 1590 -1470 {
lab=result[1]}
N 1620 -1560 1620 -1470 {
lab=result[0]}
N 1810 -1560 1810 -1470 {
lab=dn0}
N 1840 -1560 1840 -1470 {
lab=dn1}
N 1870 -1560 1870 -1470 {
lab=dn2}
N 1900 -1560 1900 -1470 {
lab=dn3}
N 1930 -1560 1930 -1470 {
lab=dn4}
N 1960 -1560 1960 -1470 {
lab=dn5}
N 1990 -1560 1990 -1470 {
lab=dn6}
N 1700 -1490 1700 -1470 {
lab=VREF}
N 1740 -1490 1740 -1470 {
lab=VSS}
N 1100 -1190 1100 -1180 {
lab=#net1}
N 840 -1140 960 -1140 {
lab=vip}
N 840 -1140 840 -1080 {
lab=vip}
N 1070 -1220 1070 -1200 {
lab=#net2}
N 1000 -1200 1030 -1200 {
lab=sample_clk}
N 1000 -1270 1000 -1200 {
lab=sample_clk}
N 1180 -1150 1260 -1150 {
lab=tah_vp}
N 1180 -1090 1220 -1090 {
lab=tah_vn}
N 890 -1100 960 -1100 {
lab=vin}
N 890 -1100 890 -1070 {
lab=vin}
N 560 -1470 560 -1440 {
lab=VDD}
N 840 -1080 840 -1040 {
lab=vip}
N 890 -1070 890 -1040 {
lab=vin}
N 1260 -1150 1270 -1150 {
lab=tah_vp}
N 1270 -1170 1270 -1150 {
lab=tah_vp}
N 1270 -1170 1290 -1170 {
lab=tah_vp}
N 1220 -1090 1270 -1090 {
lab=tah_vn}
N 1270 -1090 1270 -1070 {
lab=tah_vn}
N 1270 -1070 1290 -1070 {
lab=tah_vn}
N 1700 -770 1700 -750 {
lab=VREF}
N 1740 -770 1740 -750 {
lab=VSS}
N 2120 -1170 2200 -1170 {
lab=tah_vp}
N 2200 -1170 2200 -1150 {
lab=tah_vp}
N 2200 -1150 2220 -1150 {
lab=tah_vp}
N 2120 -1070 2200 -1070 {
lab=tah_vn}
N 2200 -1090 2200 -1070 {
lab=tah_vn}
N 2200 -1090 2220 -1090 {
lab=tah_vn}
N 3140 -1120 3270 -1120 {
lab=result[0:7]}
N 1440 -690 1440 -670 {
lab=result[6]}
N 1470 -690 1470 -670 {
lab=result[5]}
N 1500 -690 1500 -670 {
lab=result[4]}
N 1530 -690 1530 -670 {
lab=result[3]}
N 1560 -690 1560 -670 {
lab=result[2]}
N 1590 -690 1590 -670 {
lab=result[1]}
N 1620 -690 1620 -670 {
lab=result[0]}
N 1810 -690 1810 -670 {
lab=result[6]}
N 1840 -690 1840 -670 {
lab=result[5]}
N 1870 -690 1870 -670 {
lab=result[4]}
N 1900 -690 1900 -670 {
lab=result[3]}
N 1930 -690 1930 -670 {
lab=result[2]}
N 1960 -690 1960 -670 {
lab=result[1]}
N 1990 -690 1990 -670 {
lab=result[0]}
C {/foss/designs/goss_test/module/cdac/cdac_half.sym} 890 -1110 0 0 {name=x1}
C {/foss/designs/goss_test/module/cdac/cdac_half.sym} 890 -1130 2 1 {name=x2}
C {devices/lab_wire.sym} 1740 -1490 0 0 {name=p2 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1740 -765 2 1 {name=p4 sig_type=std_logic lab=VSS}
C {devices/code.sym} 975 -1480 0 0 {name=s1 only_toplevel=false value="

.lib /foss/pdks/sky130A/libs.tech/ngspice/sky130.lib.spice tt
.include /foss/pdks/sky130A/libs.ref/sky130_fd_sc_hd/spice/sky130_fd_sc_hd.spice
.save all 
.temp = 25
.tran 10p 400n
.OPTIONS savecurrents

.control
	run
        
	plot v(sw) v(tah_vp)-v(tah_vn)+0.9 vip vin
	let str = (inp-inn)*30+0.9
	plot V(EXT_CLK)-2 V(sample_clk) V(EOB)+2 V(READY)+4 V(sar_clk)+6 V(COMP_RESULT)+8 V(str)+8
	plot V(\\"tempD[0]\\") V(\\"tempD[1]\\")+2 V(\\"tempD[2]\\")+4 V(\\"tempD[3]\\")+6 V(\\"tempD[4]\\")+8 V(\\"tempD[5]\\")+10 V(\\"tempD[6]\\")+12 V(\\"tempD[7]\\")+14 V(sar_clk) V(sar_clk)+2 V(sar_clk)+4 V(sar_clk)+6 V(sar_clk)+8 V(sar_clk)+10 V(sar_clk)+12 V(sar_clk)+14 V(EOB)-2 
	plot V(\\"result[0]\\") V(\\"result[1]\\")+2 V(\\"result[2]\\")+4 V(\\"result[3]\\")+6 V(\\"result[4]\\")+8 V(\\"result[5]\\")+10 V(\\"result[6]\\")+12 V(\\"result[7]\\")+14
 	plot V(str) V(X)+2 V(Y)+2 V(Q)-2 V(P)-2 V(X_drive)+4 V(Y_drive)+4
	 
.endc
"
}
C {sky130_fd_pr/corner.sym} 845 -1480 0 0 {name=CORNER only_toplevel=false corner=tt}
C {devices/vsource.sym} 740 -1410 0 0 {name=V11 value=0.9}
C {devices/gnd.sym} 740 -1380 0 0 {name=l17 lab=GND}
C {devices/vsource.sym} 660 -1410 0 0 {name=V12 value=0}
C {devices/gnd.sym} 660 -1380 0 0 {name=l18 lab=GND}
C {devices/lab_pin.sym} 660 -1440 0 0 {name=p15 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 740 -1440 0 0 {name=p9 sig_type=std_logic lab=VREF}
C {/foss/designs/goss_test/module/tah/tah.sym} 1030 -1120 0 0 {name=x21}
C {devices/lab_wire.sym} 950 -1140 0 0 {name=p29 sig_type=std_logic lab=vip

}
C {devices/lab_wire.sym} 1250 -1090 0 0 {name=p30 sig_type=std_logic lab=tah_vn
}
C {devices/lab_wire.sym} 1250 -1150 0 0 {name=p31 sig_type=std_logic lab=tah_vp
}
C {devices/lab_wire.sym} 950 -1100 0 0 {name=p32 sig_type=std_logic lab=vin

}
C {devices/gnd.sym} 1100 -1040 0 0 {name=l25 lab=GND}
C {devices/vdd.sym} 1100 -1200 0 0 {name=l26 lab=VDD}
C {devices/vsource.sym} 560 -1410 0 0 {name=V17 value=1.8
}
C {devices/gnd.sym} 560 -1380 0 0 {name=l27 lab=GND}
C {devices/vdd.sym} 560 -1470 0 0 {name=l28 lab=VDD}
C {devices/lab_wire.sym} 1700 -1490 0 0 {name=p1 sig_type=std_logic lab=VREF}
C {devices/lab_wire.sym} 1700 -765 2 1 {name=p3 sig_type=std_logic lab=VREF}
C {devices/lab_wire.sym} 1740 -1490 0 0 {name=p7 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1440 -1485 0 0 {name=p25 sig_type=std_logic lab=result[6]}
C {devices/lab_wire.sym} 1470 -1495 0 0 {name=p26 sig_type=std_logic lab=result[5]}
C {devices/lab_wire.sym} 1500 -1485 0 0 {name=p27 sig_type=std_logic lab=result[4]}
C {devices/lab_wire.sym} 1530 -1485 0 0 {name=p35 sig_type=std_logic lab=result[3]}
C {devices/lab_wire.sym} 1560 -1485 0 0 {name=p36 sig_type=std_logic lab=result[2]}
C {devices/lab_wire.sym} 1590 -1485 0 0 {name=p37 sig_type=std_logic lab=result[1]}
C {devices/lab_wire.sym} 1620 -1485 0 0 {name=p38 sig_type=std_logic lab=result[0]
}
C {devices/vsource.sym} 840 -1010 0 0 {name=V5 value=1.35}
C {devices/gnd.sym} 840 -980 0 0 {name=l23 lab=GND}
C {devices/vsource.sym} 890 -1010 0 0 {name=V6 value=0.45}
C {devices/gnd.sym} 890 -980 0 0 {name=l5 lab=GND}
C {/foss/designs/goss_test/module/comparator/comp.sym} 2390 -1120 0 0 {name=x4}
C {devices/lab_pin.sym} 2550 -1140 2 0 {name=p33 sig_type=std_logic lab=COMP_RESULT}
C {devices/lab_pin.sym} 2450 -1050 2 0 {name=p34 sig_type=std_logic lab=READY}
C {devices/lab_pin.sym} 2350 -1010 2 0 {name=p39 sig_type=std_logic lab=sar_clk}
C {devices/lab_pin.sym} 2310 -1010 0 0 {name=p40 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 2310 -1220 0 0 {name=p41 sig_type=std_logic lab=VDD}
C {devices/noconn.sym} 2550 -1100 2 0 {name=l6}
C {devices/lab_pin.sym} 2450 -1230 2 0 {name=p44 sig_type=std_logic lab=X}
C {devices/lab_pin.sym} 2450 -1210 2 0 {name=p45 sig_type=std_logic lab=Y}
C {devices/lab_pin.sym} 2450 -1270 2 0 {name=p65 sig_type=std_logic lab=P}
C {devices/lab_pin.sym} 2450 -1250 2 0 {name=p66 sig_type=std_logic lab=Q}
C {devices/lab_pin.sym} 2450 -1190 2 0 {name=p67 sig_type=std_logic lab=X_drive}
C {devices/lab_pin.sym} 2450 -1170 2 0 {name=p68 sig_type=std_logic lab=Y_drive}
C {devices/vsource.sym} 540 -1280 0 0 {name=V36 value="PULSE(0 1.8 0 5p 5p 50n 100n)"}
C {devices/gnd.sym} 540 -1250 0 0 {name=l3 lab=GND}
C {devices/lab_pin.sym} 540 -1310 2 0 {name=p42 sig_type=std_logic lab=EXT_CLK}
C {jh_top.sym} 2990 -1110 0 0 {name=x3}
C {devices/lab_pin.sym} 2840 -1140 0 0 {name=p43 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 2840 -1120 0 0 {name=p69 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 2840 -1100 0 0 {name=p70 sig_type=std_logic lab=EXT_CLK}
C {devices/lab_pin.sym} 2840 -1080 0 0 {name=p71 sig_type=std_logic lab=COMP_RESULT}
C {devices/lab_pin.sym} 2840 -1060 0 0 {name=p72 sig_type=std_logic lab=READY}
C {devices/lab_pin.sym} 3140 -1160 2 0 {name=p73 sig_type=std_logic lab=sar_clk}
C {devices/lab_pin.sym} 3140 -1140 2 0 {name=p74 sig_type=std_logic lab=EOB}
C {devices/lab_pin.sym} 3140 -1120 2 0 {name=p75 sig_type=std_logic lab=result[0:7]}
C {devices/lab_pin.sym} 3140 -1100 2 0 {name=p76 sig_type=std_logic lab=tempD[0:7]}
C {devices/lab_pin.sym} 3140 -1080 2 0 {name=p77 sig_type=std_logic lab=sample_clk}
C {devices/capa.sym} 3270 -1090 0 0 {name=C2
m=1
value=10f
footprint=1206
device="ceramic capacitor"}
C {devices/lab_pin.sym} 3270 -1060 3 0 {name=p78 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 2840 -1160 0 0 {name=p79 sig_type=std_logic lab=sel_bit[0:1]}
C {devices/lab_pin.sym} 1000 -1270 2 0 {name=p80 sig_type=std_logic lab=sample_clk}
C {sky130_stdcells/inv_1.sym} 1070 -1260 1 0 {name=x5 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} 1070 -1300 2 0 {name=p81 sig_type=std_logic lab=sample_clk}
C {devices/vdd.sym} 1160 -840 0 0 {name=l4 lab=VGND}
C {devices/gnd.sym} 1010 -780 0 0 {name=l19 lab=GND}
C {devices/vsource.sym} 1010 -810 0 0 {name=V13 value=1.8}
C {devices/vdd.sym} 1060 -840 0 0 {name=l20 lab=VNB}
C {devices/gnd.sym} 1060 -780 0 0 {name=l21 lab=GND}
C {devices/vsource.sym} 1060 -810 0 0 {name=V14 value=0}
C {devices/vdd.sym} 1110 -840 0 0 {name=l29 lab=VPB}
C {devices/gnd.sym} 1110 -780 0 0 {name=l30 lab=GND}
C {devices/vsource.sym} 1110 -810 0 0 {name=V37 value=1.8}
C {devices/vdd.sym} 1010 -840 0 0 {name=l31 lab=VPWR}
C {devices/gnd.sym} 1160 -780 0 0 {name=l32 lab=GND}
C {devices/vsource.sym} 1160 -810 0 0 {name=V38 value=0}
C {devices/lab_pin.sym} 850 -830 0 0 {name=p120 sig_type=std_logic lab=sel_bit[0]}
C {devices/lab_pin.sym} 850 -800 0 0 {name=p82 sig_type=std_logic lab=sel_bit[1]}
C {devices/vsource.sym} 880 -800 3 0 {name=V39 value=1.8}
C {devices/gnd.sym} 910 -800 0 0 {name=l33 lab=GND}
C {devices/vsource.sym} 880 -830 3 0 {name=V40 value=1.8}
C {devices/gnd.sym} 910 -830 0 0 {name=l34 lab=GND}
C {sky130_stdcells/inv_1.sym} 1440 -730 3 0 {name=x6 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/inv_1.sym} 1470 -730 3 0 {name=x7 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/inv_1.sym} 1500 -730 3 0 {name=x8 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/inv_1.sym} 1530 -730 3 0 {name=x9 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/inv_1.sym} 1560 -730 3 0 {name=x10 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/inv_1.sym} 1590 -730 3 0 {name=x11 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/inv_1.sym} 1620 -730 3 0 {name=x12 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR prefix=sky130_fd_sc_hd__ }
C {devices/lab_wire.sym} 1440 -675 0 0 {name=p5 sig_type=std_logic lab=result[6]}
C {devices/lab_wire.sym} 1470 -675 0 0 {name=p6 sig_type=std_logic lab=result[5]}
C {devices/lab_wire.sym} 1500 -675 0 0 {name=p8 sig_type=std_logic lab=result[4]}
C {devices/lab_wire.sym} 1530 -675 0 0 {name=p10 sig_type=std_logic lab=result[3]}
C {devices/lab_wire.sym} 1560 -675 0 0 {name=p11 sig_type=std_logic lab=result[2]}
C {devices/lab_wire.sym} 1590 -675 0 0 {name=p12 sig_type=std_logic lab=result[1]}
C {devices/lab_wire.sym} 1620 -675 0 0 {name=p13 sig_type=std_logic lab=result[0]
}
C {devices/lab_wire.sym} 1990 -1485 0 1 {name=p14 sig_type=std_logic lab=result[6]}
C {devices/lab_wire.sym} 1960 -1495 0 1 {name=p16 sig_type=std_logic lab=result[5]}
C {devices/lab_wire.sym} 1930 -1485 0 1 {name=p17 sig_type=std_logic lab=result[4]}
C {devices/lab_wire.sym} 1900 -1485 0 1 {name=p18 sig_type=std_logic lab=result[3]}
C {devices/lab_wire.sym} 1870 -1485 0 1 {name=p19 sig_type=std_logic lab=result[2]}
C {devices/lab_wire.sym} 1840 -1485 0 1 {name=p20 sig_type=std_logic lab=result[1]}
C {devices/lab_wire.sym} 1810 -1485 0 1 {name=p21 sig_type=std_logic lab=result[0]
}
C {sky130_stdcells/inv_1.sym} 1810 -730 3 0 {name=x13 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/inv_1.sym} 1840 -730 3 0 {name=x14 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/inv_1.sym} 1870 -730 3 0 {name=x15 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/inv_1.sym} 1900 -730 3 0 {name=x16 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/inv_1.sym} 1930 -730 3 0 {name=x17 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/inv_1.sym} 1960 -730 3 0 {name=x18 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/inv_1.sym} 1990 -730 3 0 {name=x19 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR prefix=sky130_fd_sc_hd__ }
C {devices/lab_wire.sym} 1810 -675 0 0 {name=p22 sig_type=std_logic lab=result[6]}
C {devices/lab_wire.sym} 1840 -675 0 0 {name=p23 sig_type=std_logic lab=result[5]}
C {devices/lab_wire.sym} 1870 -675 0 0 {name=p24 sig_type=std_logic lab=result[4]}
C {devices/lab_wire.sym} 1900 -675 0 0 {name=p28 sig_type=std_logic lab=result[3]}
C {devices/lab_wire.sym} 1930 -675 0 0 {name=p46 sig_type=std_logic lab=result[2]}
C {devices/lab_wire.sym} 1960 -675 0 0 {name=p47 sig_type=std_logic lab=result[1]}
C {devices/lab_wire.sym} 1990 -675 0 0 {name=p48 sig_type=std_logic lab=result[0]
}
