v {xschem version=3.4.0 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {/foss/designs/goss_test/module/vref_gen/sw_vref_gen.sym} 40 -30 0 0 {name=x1}
C {/foss/designs/goss_test/module/vref_gen/sw_vref_gen.sym} 210 -30 0 0 {name=x2}
