v {xschem version=3.4.0 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {/foss/designs/goss_test/module/vref_gen/sw_vref_gen.sym} 160 -40 0 0 {}
