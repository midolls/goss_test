v {xschem version=3.4.0 file_version=1.2
}
G {}
K {}
V {}
S {type=subcircuit
format="@name @pinlist @symname"
template="name=x1"}
E {}
